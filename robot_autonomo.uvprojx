# Keil uVision project robot_autonomo.uvprojx, settings and files
target TM4123 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C1230H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot_autonomo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c
  group Head
    ./: head.c head.h
  group Docs
    ./: Pin_connections.txt
  group Timer
    ./: delay.c delay.h
  group Lights
    ./: light.h light.s
  group Neck
    ./: neck.c neck.h
  group Limbs
    ./: limbs.c limbs.h limbs.s
  group Tail
    ./: tail.h tail.s
  group Behaviour
    ./: play_around.c play_Around.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
